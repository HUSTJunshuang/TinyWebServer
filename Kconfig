## Kconfig
```kconfig
mainmenu "WebServer Config"

menu "Test"
config BOOL_ARG
    bool "test bool"
    default n

endmenu
```
